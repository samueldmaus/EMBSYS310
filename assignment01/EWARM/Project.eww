<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\assignment02\assignment02.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\assignment03\assignment03.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Hello_World.ewp</path>
    </project>
    <batchBuild />
</workspace>
